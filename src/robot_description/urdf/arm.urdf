Commit message: Working ik!

File: src/robot_description/urdf/arm.urdf (robot description, URDF)
Before this commit: robot arm, 7 links, 6 joints
Links:
- link base: mass 0.152298 -> None
